# Keil uVision project miniOs.uvprojx, settings and files
target mini简易示波器 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: miniOs +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\HARDWARE;.\HARDWARE\ADC;.\HARDWARE\DAC;.\HARDWARE\IIC;.\HARDWARE\KEY;.\HARDWARE\LED;.\HARDWARE\OLED;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\USR;.\HARDWARE\DMA;.\HARDWARE\TIMER;.\FFT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group HARDWARE
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/DAC/: dac.c
    ./HARDWARE/ADC/: adc.c
    ./HARDWARE/DMA/: dma.c
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/OLED/: OLED_I2C.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group MAIN
    ./USR/: main.c DMA_DAC_TMR.c ADC_DMA_TMR.c dataMessg.c
  group FFT
    ./FFT/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
